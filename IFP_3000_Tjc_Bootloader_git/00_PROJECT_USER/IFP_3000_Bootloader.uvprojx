# Keil uVision project IFP_3000_Bootloader.uvprojx, settings and files
target IFP_3000_Bootloader (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IFP_3000_Bootloader +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\00_PROJECT_USER;..\01_FWLIB\STM32F10x_FWLib\inc;..\02_CORE;..\03_UCOSIII\uC-CPU;..\03_UCOSIII\uC-LIB;..\03_UCOSIII\UCOS_BSP;..\03_UCOSIII\uCOS_CONFIG;..\03_UCOSIII\uCOS-III\Source;..\03_UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\03_UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\03_UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\04_DRIVER_HARDWARE\LED;..\05_SYSTEM\delay;..\05_SYSTEM\sys;..\05_SYSTEM\usart;..\06_MALLOC;..\07_USMART;..\08_MANGEMENT;..\09_FUNCTION\Func_IFP_300_Drv;..\10_GLOBAL;..\04_DRIVER_HARDWARE\BSP\BSP_Gpio;..\04_DRIVER_HARDWARE\BSP\BSP_Uart;..\04_DRIVER_HARDWARE\BSP\BSP_Adc;..\04_DRIVER_HARDWARE\Device\Drv_PWM_TimerDriven;..\04_DRIVER_HARDWARE\BSP\BSP_Timer;..\04_DRIVER_HARDWARE\Device\Drv_StepMotor;..\04_DRIVER_HARDWARE\Device\Drv_MotionControlComponents;..\04_DRIVER_HARDWARE\Device\Drv_AT24C32;..\04_DRIVER_HARDWARE\Device\Drv_SimulateIic;..\04_DRIVER_HARDWARE\Device\Drv_MAX5402EUA;..\04_DRIVER_HARDWARE\Device\Drv_SimulateSpi;..\04_DRIVER_HARDWARE\Device\Drv_Flash_P25Q32h;..\04_DRIVER_HARDWARE\BSP\BSP_Spi;..\04_DRIVER_HARDWARE\BSP\BSP_Sys;..\04_DRIVER_HARDWARE\Device\Drv_AD7685;..\04_DRIVER_HARDWARE\Device\Drv_HardAD7685;..\04_DRIVER_HARDWARE\Device\Drv_HardMAX5402EUA;..\09_FUNCTION\Func_Config;..\09_FUNCTION\Func_ANSI;..\09_FUNCTION\Func_Tjc4832t;..\09_FUNCTION\Func_MA1100_User_Interface;..\09_FUNCTION\Func_MA1100_Queue;..\09_FUNCTION\Func_ADHandler;..\09_FUNCTION\Func_GY_K950E;..\09_FUNCTION\Func_Common;..\09_FUNCTION\Func_Motor;..\09_FUNCTION\Func_LogIn;..\09_FUNCTION\Func_BarCode;..\09_FUNCTION\Func_Time;..\09_FUNCTION\Func_WIFIE103W01;..\04_DRIVER_HARDWARE\Device\Drv_WIFIE103W01;..\04_DRIVER_HARDWARE\Device\Drv_Tjc4832t;..\09_FUNCTION\Func_Error;..\06_MALLOC;..\04_DRIVER_HARDWARE\Device\Drv_MLX_90614;..\09_FUNCTION\Func_Lis;..\09_FUNCTION\Func_Bluetooth;..\04_DRIVER_HARDWARE\Device\Drv_Bluetooth;..\09_FUNCTION\Func_Electric;..\09_FUNCTION\Func_Tjc_Bootloader;..\09_FUNCTION\Func_Dma_Uart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../04_DRIVER_HARDWARE/LED/: led.c
  group SYSTEM
    ../05_SYSTEM/delay/: delay.c
    ../05_SYSTEM/sys/: sys.c
    ../05_SYSTEM/usart/: usart.c
  group CORE
    ../02_CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../01_FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group UCOSIII-BSP
    ../03_UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../03_UCOSIII/uC-CPU/: cpu_core.c
    ../03_UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../03_UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../03_UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../03_UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../03_UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOSIII_CONFIG
    ../03_UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group MANGEMENT
    ../08_MANGEMENT/: Task.c
  group FUNCTION
    ../09_FUNCTION/Func_IFP_300_Drv/: Func_IFP_300_Drv.c
    ../09_FUNCTION/Func_Config/: Func_Config.c
    ../09_FUNCTION/Func_ANSI/: Func_Ansi.c
    ../09_FUNCTION/Func_Tjc4832t/: Func_Tjc4832t.c
    ../09_FUNCTION/Func_MA1100_User_Interface/: Func_MA1100_User_Interface.c
    ../09_FUNCTION/Func_MA1100_Queue/: Func_MA1100_Queue.c
    ../09_FUNCTION/Func_ADHandler/: Func_ADHandler.c
    ../09_FUNCTION/Func_GY_K950E/: Func_GY_K950E.c
    ../09_FUNCTION/Func_Common/: Func_Common.c
    ../09_FUNCTION/Func_Motor/: Func_Motor.c
    ../09_FUNCTION/Func_LogIn/: Func_LogIn.c
    ../09_FUNCTION/Func_BarCode/: Func_BarCode.c Func_BarCode_2.c
    ../09_FUNCTION/Func_Time/: Func_Time.c
    ../09_FUNCTION/Func_WIFIE103W01/: Func_WIFIE103W01.c
    ../09_FUNCTION/Func_Error/: Func_Error.c
    ../09_FUNCTION/Func_Lis/: Func_Lis.c
    ../09_FUNCTION/Func_Bluetooth/: Func_Bluetooth.c
    ../09_FUNCTION/Func_Electric/: Func_Electric.c
    ../09_FUNCTION/Func_Tjc_Bootloader/: Func_Tjc_Bootloader.c
    ../09_FUNCTION/Func_Dma_Uart/: Func_Dma_Uart.c
  group GLOBAL
    ../10_GLOBAL/: Global_Variable.c
  group HW/DRIVER/BSP
    ../04_DRIVER_HARDWARE/BSP/BSP_Gpio/: BSP_Gpio.c
    ../04_DRIVER_HARDWARE/BSP/BSP_Uart/: BSP_Uart.c
    ../04_DRIVER_HARDWARE/BSP/BSP_Adc/: BSP_Adc.c
    ../04_DRIVER_HARDWARE/BSP/BSP_Timer/: BSP_Timer.c
    ../04_DRIVER_HARDWARE/BSP/BSP_Spi/: BSP_Spi.c
    ../04_DRIVER_HARDWARE/BSP/BSP_Sys/: BSP_Sys.c
  group HW/DRIVER/DIR
    ../04_DRIVER_HARDWARE/Device/Drv_PWM_TimerDriven/: Drv_PWM_TimerDriven.c
    ../04_DRIVER_HARDWARE/Device/Drv_StepMotor/: Drv_StepMotor.c
    ../04_DRIVER_HARDWARE/Device/Drv_MotionControlComponents/: Drv_MotionControlComponents.c
    ../04_DRIVER_HARDWARE/Device/Drv_AT24C32/: Drv_AT24C32.c
    ../04_DRIVER_HARDWARE/Device/Drv_SimulateIic/: Drv_SimulateIic.c
    ../04_DRIVER_HARDWARE/Device/Drv_MAX5402EUA/: Drv_MAX5402EUA.c
    ../04_DRIVER_HARDWARE/Device/Drv_SimulateSpi/: Drv_SimulateSpi.c
    ../04_DRIVER_HARDWARE/Device/Drv_Flash_P25Q32h/: Drv_Flash_P25Q32h.c
    ../04_DRIVER_HARDWARE/Device/Drv_AD7685/: Drv_AD7685.c
    ../04_DRIVER_HARDWARE/Device/Drv_HardAD7685/: Drv_HardAD7685.c
    ../04_DRIVER_HARDWARE/Device/Drv_HardMAX5402EUA/: Drv_HardMAX5402EUA.c
    ../04_DRIVER_HARDWARE/Device/Drv_WIFIE103W01/: Drv_WIFIE103W01.c
    ../04_DRIVER_HARDWARE/Device/Drv_Tjc4832t/: Drv_Tjc4832t.c
    ../04_DRIVER_HARDWARE/Device/Drv_MLX_90614/: drv_mlx90614.c
    ../04_DRIVER_HARDWARE/Device/Drv_Bluetooth/: Drv_Bluetooth.c
  group MYMALLOC
    ../06_MALLOC/: malloc.c
